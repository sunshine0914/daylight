# Keil uVision project Final-智能环境温控系统.uvproj, settings and files
target Finally (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Final-智能环境温控系统 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\AT24C02 EEPROM IIC 总线;.\MAIN;.\PUBLIC;.\DS1302 实时时钟;.\DS18B20 单总线温度传感器;.\LCD1602 液晶驱动;.\NEC 红外接收解码;.\UART 串口通信 + RS485 总线;.\五线四相步进电机驱动;.\独立按键输入;.\蜂鸣器 + 风扇直流开关输出;.\LCD1602 液晶驱动
  group PUBLIC
    ./PUBLIC/: public.c public.h
  group AT24C02 EEPROM IIC 总线
    ./AT24C02 EEPROM IIC 总线/: at24c02.c at24c02.h iic.c iic.h bus.c bus.h
  group DS18B20 单总线温度传感器
    ./DS18B20 单总线温度传感器/: ds18b20.c ds18b20.h
  group DS1302 实时时钟
    ./DS1302 实时时钟/: ds1302.h ds1302.c
  group LCD1602 液晶驱动
    ./LCD1602 液晶驱动/: lcd1602.c lcd1602.h
  group NEC 红外接收解码
    ./NEC 红外接收解码/: ired.c ired.h
  group 独立按键输入
    ./独立按键输入/: in_key.c in_key.h
  group 蜂鸣器 + 风扇直流开关输出
    ./蜂鸣器 + 风扇直流开关输出/: buzzer_fan.h buzzer_fan.c
  group MAIN
    ./MAIN/: main.c smg.c smg.h key.c key.h
